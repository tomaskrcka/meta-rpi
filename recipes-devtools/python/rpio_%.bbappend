SRC_URI = "https://pypi.python.org/packages/source/R/RPIO/${SRCNAME}-${PV}.tar.gz"

