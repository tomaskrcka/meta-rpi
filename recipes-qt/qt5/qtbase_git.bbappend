PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2 linuxfb tslib sql-psql"

DEPENDS += "userland"
